# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Device;.\sys;.\systick;.\dht11;.\1602;.\GY-30;.\flash;.\sds011;.\RTC;.\arofene
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: code.c
  group systick
    ./systick/: core_cm3.c
  group sys
    ./sys/: delay.c sys.c
  group dht11
    ./dht11/: dht11.c
  group wifi
    ./wifi/: wifi.c
  group 1602
    ./1602/: lcd1602.c
  group GY-30
    ./GY-30/: bh1750.c
  group flash
    ./flash/: flash.c
  group Sds011
    ./sds011/: sds011.c
  group RTC
    ./RTC/: rtc.c
  group arofene
    ./: arofene.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
